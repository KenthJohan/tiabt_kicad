# Repository KenthJohan/tiabt_kicad (continued)

## KiCad design project1/project1.kicad_pcb (continued)

Board: 4 copper layers, 100.0 x 100.0 mm, 299 parts (0 on the bottom side), 139 nets.
