# Repository KenthJohan/tiabt_kicad

File README.md:

# TIABT

This circuit is used for controlling LEDs and measure photodiodes.

Specification
* Power input
    * 16V to 20V
    * Max 0.2A
* 8 channels current measurment
    * 10pA resolution from 1µA current offset
    * Optional 1µA current subtractor
    * Supports large range of feedback resistor in TIA
* 7 channels LED driver
    * Software controlled current
    * 0.3mA to 2.14mA, 255 steps
    * Up to 12V
    * Enable and Disable

## Board

## Box

## 10pA measuement of one channel
* Feedback resistor is `100Mohm`
* Current subtractor, `1µA` 
* `1µA` plus `n*10pA`, n=1,2,3,4,5,6 steps from SMU with coaxial cable
* SMU is Keysight B2910BL

## KiCad design project1/project1.kicad_pcb

Parts:
C4, C5, C7, C11, C13: 0.1µF; C_0603_1608Metric
C6: 1uF; C_0603_1608Metric
C8: 10nF; C_0603_1608Metric
C9: 2.2uF; C_0603_1608Metric
C10, C12: 1µF; C_0603_1608Metric
C15, C19: 1nF; C_0603_1608Metric
C113, C121: 1uF; C_0805_2012Metric
C114, C122: 4.7uF; C_0805_2012Metric
D1, D2, D3: LED; LED_0603_1608Metric
H1, H2, H3, H4, H5, H6: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J3, J4, J5, J6, J8, J9: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x06_Pin; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J7, J10: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R5: 10k; R_0603_1608Metric
R35: 300k; R_0603_1608Metric
R36, R44, R45, R71: R; R_0603_1608Metric
R43: 91k; R_0603_1608Metric
R54: 360k; R_0603_1608Metric
R55: 30k; R_0603_1608Metric
R70: 200k; R_0603_1608Metric
U2: MCP3564-E/ST; TSSOP-20_4.4x6.5mm_P0.65mm
U4, U5: SOIC-8_3.9x4.9mm_P1.27mm
U6: MAX6070AAUT12+T; SOT-23-6
U7: LP2985-3.3; SOT-23-5
U38: PinHeader_2x15_P2.54mm_Vertical

Connections:
5V: C4.1, C6.1, C19.1, C114.1, J4.2, R35.1, R44.1, U4.1 (VOUT), U6.3 (EN), U6.4 (IN), U7.1 (VIN), U7.3 (ON/~OFF); also elsewhere on the board
5V_EN: J6.1, J10.1, R71.2, U4.5 (EN)
13V: C15.1, C113.1, C122.1, J5.2, J10.2, R45.1, R54.1, U4.4 (VIN), U5.1 (VOUT); also elsewhere on the board
13V_EN: J6.2, J7.1, R70.2, U5.5 (EN)
/ADC_AVDD: C9.1, C10.2, C11.2, U2.1 (AVDD), U7.5 (VOUT)
/ADC_REFIN+: C7.1, U2.4 (REFIN+), U6.5 (OUTS), U6.6 (OUTF)
ADC_CH0: U2.12 (CH7); also elsewhere on the board
ADC_CH1: U2.11 (CH6); also elsewhere on the board
ADC_CH2: U2.10 (CH5); also elsewhere on the board
ADC_CH3: U2.9 (CH4); also elsewhere on the board
ADC_CH4: U2.8 (CH3); also elsewhere on the board
ADC_CH5: U2.7 (CH2); also elsewhere on the board
ADC_CH6: U2.6 (CH1); also elsewhere on the board
ADC_CH7: U2.5 (CH0); also elsewhere on the board
ADC_CS: J2.1, U2.13 (*CS)
ADC_INT: J2.5, R5.2, U2.17 (*IRQ/MDAT)
ADC_MCK: J2.6, U2.18 (MCLKIN)
ADC_SCK: J2.2, U2.14 (SCK)
ADC_SDI: J2.3, U2.15 (SDI)
ADC_SDO: J2.4, U2.16 (SDO)
BATT_14V_24V: C121.1, J1.2, J7.2, U5.4 (VIN)
DPOT_A_SCL: J8.2; also elsewhere on the board
DPOT_A_SDA: J8.1; also elsewhere on the board
DPOT_B_SCL: J9.2; also elsewhere on the board
DPOT_B_SDA: J9.1; also elsewhere on the board
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, C113.2, C114.2, C121.2, C122.2, D1.1 (K), D2.1 (K), D3.1 (K), H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, J1.1, J3.1, J4.1, J5.1, R43.2, R55.2, R70.1, R71.1, U2.2 (AGND), U2.3 (REFIN-), U2.19 (DGND), U4.2 (GND), U4.3 (GND), U4.6 (GND), U4.7 (GND), U5.2 (GND), U5.3 (GND), U5.6 (GND), U5.7 (GND), U6.2 (GND), U7.2 (GND), U38.1 (OPD1_ANODE), U38.4 (OLED1_CATHODE), U38.5 (OPD2_ANODE), U38.8 (OLED2_CATHODE), U38.9 (OPD3_ANODE), U38.12 (OLED3_CATHODE), U38.13 (OPD4_ANODE), U38.16 (OLED4_CATHODE), U38.17 (OPD5_ANODE), U38.20 (OLED5_CATHODE), U38.21 (OPD6_ANODE), U38.24 (OLED6_CATHODE), U38.25 (OPD7_ANODE), U38.28 (OLED7_CATHODE), U38.29 (OPD8_ANODE); also elsewhere on the board
unnamed: D1.2 (A), R44.2
unnamed: D2.2 (A), R36.2
unnamed: D3.2 (A), R45.2
unnamed: C19.2, R35.2, R43.1, U4.8 (ADJ)
unnamed: C15.2, R54.2, R55.1, U5.8 (ADJ)
unnamed: C5.1, U6.1 (FILTER)
unnamed: C8.1, U7.4 (BP)
OLED1: U38.3 (OLED1_ANODE); also elsewhere on the board
OLED2: U38.7 (OLED2_ANODE); also elsewhere on the board
OLED3: U38.11 (OLED3_ANODE); also elsewhere on the board
OLED4: U38.15 (OLED4_ANODE); also elsewhere on the board
OLED5: U38.19 (OLED5_ANODE); also elsewhere on the board
OLED6: U38.23 (OLED6_ANODE); also elsewhere on the board
OLED7: U38.27 (OLED7_ANODE); also elsewhere on the board
OPD1_CATHODE: U38.2 (OPD1_CATHODE); also elsewhere on the board
OPD2_CATHODE: U38.6 (OPD2_CATHODE); also elsewhere on the board
OPD3_CATHODE: U38.10 (OPD3_CATHODE); also elsewhere on the board
OPD4_CATHODE: U38.14 (OPD4_CATHODE); also elsewhere on the board
OPD5_CATHODE: U38.18 (OPD5_CATHODE); also elsewhere on the board
OPD6_CATHODE: U38.22 (OPD6_CATHODE); also elsewhere on the board
OPD7_CATHODE: U38.26 (OPD7_CATHODE); also elsewhere on the board
OPD8_CATHODE: U38.30 (OPD8_CATHODE); also elsewhere on the board
VL: C12.1, C13.1, J3.2, R5.1, R36.1, U2.20 (DVDD); also elsewhere on the board

Notes on the sheet:
VADJ = 1.18V R1 = R2 x (VOUT/VADJ - 1) R1/R2 = VOUT/VADJ - 1 R1/R2 + 1 = VOUT/VADJ VADJ * (R1/R2 + 1) = VOUT 1.18 * (360k/30k + 1) = 15.34V
Cathode will have negative voltage from photocurrent. TIA expect negative voltage on inverting input (IN-)
R1 = R2 x (VOUT/VADJ - 1) VOUT = 1.18 * (300/91+ 1) = 5.07010989011
OPD AMP
ADC
OLED drivers

Parts:
C1, C2, C41, C49: 1uF; C_0603_1608Metric
C16: 270pF; FB_C_0603_1608Metric
C17, C20: 2.2uF; C_0603_1608Metric
C18: 1µF; C_0603_1608Metric
R1: 500K; TIA_R_0603_1608Metric
R7: 10M; R_0603_1608Metric
R9: R; FB_R_1206_3216Metric
R10, R46: 2.2K; R_0603_1608Metric
U10: REF102CU; SOIC-8_3.9x4.9mm_P1.27mm
U11: OPA277UA; SOIC-8_3.9x4.9mm_P1.27mm; PARTREV 02/2019
U12: LMP7721MA; SOIC-8_3.9x4.9mm_P1.27mm
U61: OPD_TIA_Outline

Connections:
5V: C18.2, C41.2, U11.7 (V+), U12.6 (V+); also elsewhere on the board
13V: C1.2, C2.2, U10.2 (Vin); also elsewhere on the board
/amp1/AMPO: C16.2, R9.2, R10.2, U12.4 (VO)
/amp1/ISRC_+IN_0.5V: R1.2, R7.1, U11.3 (+IN)
/amp1/REFGND_0.5V: C1.1, U10.4 (GND), U11.2 (-IN), U11.6 (OUTPUT)
/amp1/REF_10.5V: R7.2, U10.6 (Vout)
ADC_CH0: C20.2, R46.1; also elsewhere on the board
GND: C2.1, C17.1, C18.1, C20.1, C41.1, C49.1, U11.4 (V-), U12.1 (IN+), U12.2 (NC), U12.3 (V-), U12.7 (NC); also elsewhere on the board
unnamed: C17.2, R10.1, R46.2
unnamed: C49.2, U10.8 (NR)
OPD1_CATHODE: C16.1, R1.1, R9.1, U12.8 (IN-); also elsewhere on the board

Parts of its further copies:
C21, C28, C40, C53, C97, C104, C111, C112, C115, C116, C117, C118, C119, C120: 2.2uF; C_0603_1608Metric
C22, C23, C24, C25, C29, C35, C36, C37, C42, C43, C44, C45, C55, C57, C61, C62, C84, C85, C86, C87, C98, C99, C100, C101, C105, C106, C107, C108: 1uF; C_0603_1608Metric
C26, C38, C47, C63, C88, C102, C109: 270pF; FB_C_0603_1608Metric
C27, C39, C51, C64, C96, C103, C110: 1µF; C_0603_1608Metric
R2, R14, R19, R25, R27, R30, R34: 10M; R_0603_1608Metric
R3, R15, R21, R26, R31, R37, R40: 500K; TIA_R_0603_1608Metric
R11, R17, R22, R28, R32, R38, R41: R; FB_R_1206_3216Metric
R13, R18, R23, R29, R33, R39, R42, R47, R48, R49, R50, R51, R52, R53: 2.2K; R_0603_1608Metric
U3, U17, U20, U23, U45, U48, U51: REF102CU; SOIC-8_3.9x4.9mm_P1.27mm
U15, U18, U21, U24, U46, U49, U52: OPA277UA; SOIC-8_3.9x4.9mm_P1.27mm; PARTREV 02/2019
U16, U19, U22, U36, U47, U50, U53: LMP7721MA; SOIC-8_3.9x4.9mm_P1.27mm
U62, U63, U64, U65, U66, U67, U68: OPD_TIA_Outline

Connections of its further copies:
5V: C25.2, C27.2, C37.2, C39.2, C45.2, C51.2, C62.2, C64.2, C87.2, C96.2, C101.2, C103.2, C108.2, C110.2, U15.7 (V+), U16.6 (V+), U18.7 (V+), U19.6 (V+), U21.7 (V+), U22.6 (V+), U24.7 (V+), U36.6 (V+), U46.7 (V+), U47.6 (V+), U49.7 (V+), U50.6 (V+), U52.7 (V+), U53.6 (V+); also elsewhere on the board
13V: C22.2, C23.2, C29.2, C35.2, C42.2, C43.2, C55.2, C57.2, C84.2, C85.2, C98.2, C99.2, C105.2, C106.2, U3.2 (Vin), U17.2 (Vin), U20.2 (Vin), U23.2 (Vin), U45.2 (Vin), U48.2 (Vin), U51.2 (Vin); also elsewhere on the board
/amp2/AMPO: C26.2, R11.2, R13.2, U16.4 (VO)
/amp2/ISRC_+IN_0.5V: R2.1, R3.2, U15.3 (+IN)
/amp2/REFGND_0.5V: C23.1, U3.4 (GND), U15.2 (-IN), U15.6 (OUTPUT)
/amp2/REF_10.5V: R2.2, U3.6 (Vout)
/amp3/AMPO: C38.2, R17.2, R18.2, U19.4 (VO)
/amp3/ISRC_+IN_0.5V: R14.1, R15.2, U18.3 (+IN)
/amp3/REFGND_0.5V: C35.1, U17.4 (GND), U18.2 (-IN), U18.6 (OUTPUT)
/amp3/REF_10.5V: R14.2, U17.6 (Vout)
/amp4/AMPO: C47.2, R22.2, R23.2, U22.4 (VO)
/amp4/ISRC_+IN_0.5V: R19.1, R21.2, U21.3 (+IN)
/amp4/REFGND_0.5V: C43.1, U20.4 (GND), U21.2 (-IN), U21.6 (OUTPUT)
/amp4/REF_10.5V: R19.2, U20.6 (Vout)
/amp5/AMPO: C63.2, R28.2, R29.2, U36.4 (VO)
/amp5/ISRC_+IN_0.5V: R25.1, R26.2, U24.3 (+IN)
/amp5/REFGND_0.5V: C57.1, U23.4 (GND), U24.2 (-IN), U24.6 (OUTPUT)
/amp5/REF_10.5V: R25.2, U23.6 (Vout)
/amp6/AMPO: C102.2, R32.2, R33.2, U50.4 (VO)
/amp6/ISRC_+IN_0.5V: R30.1, R31.2, U49.3 (+IN)
/amp6/REFGND_0.5V: C99.1, U48.4 (GND), U49.2 (-IN), U49.6 (OUTPUT)
/amp6/REF_10.5V: R30.2, U48.6 (Vout)
/amp7/AMPO: C109.2, R38.2, R39.2, U53.4 (VO)
/amp7/ISRC_+IN_0.5V: R34.1, R37.2, U52.3 (+IN)
/amp7/REFGND_0.5V: C106.1, U51.4 (GND), U52.2 (-IN), U52.6 (OUTPUT)
/amp7/REF_10.5V: R34.2, U51.6 (Vout)
/amp8/AMPO: C88.2, R41.2, R42.2, U47.4 (VO)
/amp8/ISRC_+IN_0.5V: R27.1, R40.2, U46.3 (+IN)
/amp8/REFGND_0.5V: C85.1, U45.4 (GND), U46.2 (-IN), U46.6 (OUTPUT)
/amp8/REF_10.5V: R27.2, U45.6 (Vout)
ADC_CH1: C21.2, R47.1; also elsewhere on the board
ADC_CH2: C115.2, R48.1; also elsewhere on the board
ADC_CH3: C116.2, R49.1; also elsewhere on the board
ADC_CH4: C117.2, R50.1; also elsewhere on the board
ADC_CH5: C118.2, R51.1; also elsewhere on the board
ADC_CH6: C119.2, R52.1; also elsewhere on the board
ADC_CH7: C120.2, R53.1; also elsewhere on the board
GND: C21.1, C22.1, C24.1, C25.1, C27.1, C28.1, C29.1, C36.1, C37.1, C39.1, C40.1, C42.1, C44.1, C45.1, C51.1, C53.1, C55.1, C61.1, C62.1, C64.1, C84.1, C86.1, C87.1, C96.1, C97.1, C98.1, C100.1, C101.1, C103.1, C104.1, C105.1, C107.1, C108.1, C110.1, C111.1, C112.1, C115.1, C116.1, C117.1, C118.1, C119.1, C120.1, U15.4 (V-), U16.1 (IN+), U16.2 (NC), U16.3 (V-), U16.7 (NC), U18.4 (V-), U19.1 (IN+), U19.2 (NC), U19.3 (V-), U19.7 (NC), U21.4 (V-), U22.1 (IN+), U22.2 (NC), U22.3 (V-), U22.7 (NC), U24.4 (V-), U36.1 (IN+), U36.2 (NC), U36.3 (V-), U36.7 (NC), U46.4 (V-), U47.1 (IN+), U47.2 (NC), U47.3 (V-), U47.7 (NC), U49.4 (V-), U50.1 (IN+), U50.2 (NC), U50.3 (V-), U50.7 (NC), U52.4 (V-), U53.1 (IN+), U53.2 (NC), U53.3 (V-), U53.7 (NC); also elsewhere on the board
unnamed: C28.2, R13.1, R47.2
unnamed: C40.2, R18.1, R48.2
unnamed: C53.2, R23.1, R49.2
unnamed: C97.2, R29.1, R50.2
unnamed: C104.2, R33.1, R51.2
unnamed: C111.2, R39.1, R52.2
unnamed: C112.2, R42.1, R53.2
unnamed: C24.2, U3.8 (NR)
unnamed: C36.2, U17.8 (NR)
unnamed: C44.2, U20.8 (NR)
unnamed: C61.2, U23.8 (NR)
unnamed: C86.2, U45.8 (NR)
unnamed: C100.2, U48.8 (NR)
unnamed: C107.2, U51.8 (NR)
OPD2_CATHODE: C26.1, R3.1, R11.1, U16.8 (IN-); also elsewhere on the board
OPD3_CATHODE: C38.1, R15.1, R17.1, U19.8 (IN-); also elsewhere on the board
OPD4_CATHODE: C47.1, R21.1, R22.1, U22.8 (IN-); also elsewhere on the board
OPD5_CATHODE: C63.1, R26.1, R28.1, U36.8 (IN-); also elsewhere on the board
OPD6_CATHODE: C102.1, R31.1, R32.1, U50.8 (IN-); also elsewhere on the board
OPD7_CATHODE: C109.1, R37.1, R38.1, U53.8 (IN-); also elsewhere on the board
OPD8_CATHODE: C88.1, R40.1, R41.1, U47.8 (IN-); also elsewhere on the board

Notes on the sheet:
10.1 Layout Guidelines In order to capitalize on the LMP7721's ultra-low input bias current, careful circuit layout and assembly are required. Guarding techniques are highly recommended to reduce parasitic leakage current by isolating the LMP7721's input from large voltage gradients across the PC b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
IN = Cathode IN ~= GND, virtual short IN < GND Vout = openloop_gain * (GND - IN) Vout = openloop_gain * (positive_number)
OPD current: 0.6 - 1.2 uA
I_PD
Constant current line: I = 10V / R, R > 1K
TIA
RC Filter and current protection for ADC
GND
Avoid gain saturation by raising +IN voltage over GND. V = I*R I ~= 1µA V = 1*10^(-6) * 500*10^3 = 500mV
500mV
OPD_CATHODE
Current subtractor

Parts:
C79, C81, C95, C130, C137: 1µF; C_0603_1608Metric
C80, C82, C83: 0.1μF; C_0603_1608Metric
C123: 10µF; C_1206_3216Metric
R20: 1K; R_0603_1608Metric
R56, R63: 1; R_0603_1608Metric
U41: REF5020IDGK; MSOP-8_3x3mm_P0.65mm
U42: OPA277UA; SOIC-8_3.9x4.9mm_P1.27mm; PARTREV 02/2019
U43: MCP45HV31-ST; TSSOP-14_4.4x5mm_P0.65mm
U54: OLED_Driver_Outline

Connections:
13V: C79.1, C80.1, C82.1, C95.1, U41.2 (Vin), U42.7 (V+), U43.14 (V+); also elsewhere on the board
/OLED_driver1/OLED_8V_BUFFERED: C81.2, C95.2, C123.2, C130.2, C137.1, R63.1, U41.4 (GND)
/OLED_driver1/RELATIVE_2.048V_ABSOLTE_10V: C130.1, R20.1, R56.1, U41.6 (Vout)
DPOT_A_SCL: U43.2 (SCL); also elsewhere on the board
DPOT_A_SDA: U43.4 (SDA); also elsewhere on the board
GND: C79.2, C80.2, C82.2, C83.2, C137.2, U42.4 (V-), U43.3 (A1), U43.5 (A0), U43.6 (~WLAT), U43.9 (DGND), U43.10 (V-); also elsewhere on the board
unnamed: C123.1, R56.2
unnamed: C81.1, U41.5 (Trim/NR)
unnamed: R63.2, U42.2 (-IN), U42.6 (OUTPUT)
unnamed: R20.2, U43.13 (P0A)
OLED1: U42.3 (+IN), U43.12 (P0W); also elsewhere on the board
VL: C83.1, U43.1 (VL), U43.8 (~SHDN); also elsewhere on the board

Parts of its further copies:
C3, C30, C33, C46, C52, C56, C60, C66, C69, C71, C74, C76, C89, C90, C91, C92, C93, C94, C131, C132, C133, C134, C135, C136, C138, C139, C140, C141, C142, C143: 1µF; C_0603_1608Metric
C14, C31, C32, C34, C48, C50, C54, C58, C59, C65, C67, C68, C70, C72, C73, C75, C77, C78: 0.1μF; C_0603_1608Metric
C124, C125, C126, C127, C128, C129: 10µF; C_1206_3216Metric
R4, R6, R8, R12, R16, R24: 1K; R_0603_1608Metric
R57, R58, R59, R60, R61, R62, R64, R65, R66, R67, R68, R69: 1; R_0603_1608Metric
U1, U25, U28, U31, U34, U39: REF5020IDGK; MSOP-8_3x3mm_P0.65mm
U8, U26, U29, U32, U35, U40: OPA277UA; SOIC-8_3.9x4.9mm_P1.27mm; PARTREV 02/2019
U9, U27, U30, U33, U37, U44: MCP45HV31-ST; TSSOP-14_4.4x5mm_P0.65mm
U55, U56, U57, U58, U59, U60: OLED_Driver_Outline

Connections of its further copies:
13V: C3.1, C14.1, C31.1, C33.1, C34.1, C48.1, C52.1, C54.1, C58.1, C60.1, C65.1, C67.1, C69.1, C70.1, C72.1, C74.1, C75.1, C77.1, C89.1, C90.1, C91.1, C92.1, C93.1, C94.1, U1.2 (Vin), U8.7 (V+), U9.14 (V+), U25.2 (Vin), U26.7 (V+), U27.14 (V+), U28.2 (Vin), U29.7 (V+), U30.14 (V+), U31.2 (Vin), U32.7 (V+), U33.14 (V+), U34.2 (Vin), U35.7 (V+), U37.14 (V+), U39.2 (Vin), U40.7 (V+), U44.14 (V+); also elsewhere on the board
/OLED_driver2/OLED_8V_BUFFERED: C30.2, C89.2, C124.2, C131.2, C138.1, R64.1, U1.4 (GND)
/OLED_driver2/RELATIVE_2.048V_ABSOLTE_10V: C131.1, R4.1, R57.1, U1.6 (Vout)
/OLED_driver3/OLED_8V_BUFFERED: C46.2, C90.2, C125.2, C132.2, C139.1, R65.1, U25.4 (GND)
/OLED_driver3/RELATIVE_2.048V_ABSOLTE_10V: C132.1, R6.1, R58.1, U25.6 (Vout)
/OLED_driver4/OLED_8V_BUFFERED: C56.2, C91.2, C126.2, C133.2, C140.1, R66.1, U28.4 (GND)
/OLED_driver4/RELATIVE_2.048V_ABSOLTE_10V: C133.1, R8.1, R59.1, U28.6 (Vout)
/OLED_driver5/OLED_8V_BUFFERED: C71.2, C93.2, C127.2, C134.2, C141.1, R67.1, U34.4 (GND)
/OLED_driver5/RELATIVE_2.048V_ABSOLTE_10V: C134.1, R16.1, R60.1, U34.6 (Vout)
/OLED_driver6/OLED_8V_BUFFERED: C76.2, C94.2, C128.2, C135.2, C142.1, R68.1, U39.4 (GND)
/OLED_driver6/RELATIVE_2.048V_ABSOLTE_10V: C135.1, R24.1, R61.1, U39.6 (Vout)
/OLED_driver7/OLED_8V_BUFFERED: C66.2, C92.2, C129.2, C136.2, C143.1, R69.1, U31.4 (GND)
/OLED_driver7/RELATIVE_2.048V_ABSOLTE_10V: C136.1, R12.1, R62.1, U31.6 (Vout)
DPOT_A_SCL: U9.2 (SCL), U27.2 (SCL), U30.2 (SCL); also elsewhere on the board
DPOT_A_SDA: U9.4 (SDA), U27.4 (SDA), U30.4 (SDA); also elsewhere on the board
DPOT_B_SCL: U33.2 (SCL), U37.2 (SCL), U44.2 (SCL); also elsewhere on the board
DPOT_B_SDA: U33.4 (SDA), U37.4 (SDA), U44.4 (SDA); also elsewhere on the board
GND: C3.2, C14.2, C31.2, C32.2, C33.2, C34.2, C48.2, C50.2, C52.2, C54.2, C58.2, C59.2, C60.2, C65.2, C67.2, C68.2, C69.2, C70.2, C72.2, C73.2, C74.2, C75.2, C77.2, C78.2, C138.2, C139.2, C140.2, C141.2, C142.2, C143.2, U8.4 (V-), U9.3 (A1), U9.6 (~WLAT), U9.9 (DGND), U9.10 (V-), U26.4 (V-), U27.5 (A0), U27.6 (~WLAT), U27.9 (DGND), U27.10 (V-), U29.4 (V-), U30.6 (~WLAT), U30.9 (DGND), U30.10 (V-), U32.4 (V-), U33.5 (A0), U33.6 (~WLAT), U33.9 (DGND), U33.10 (V-), U35.4 (V-), U37.3 (A1), U37.5 (A0), U37.6 (~WLAT), U37.9 (DGND), U37.10 (V-), U40.4 (V-), U44.3 (A1), U44.6 (~WLAT), U44.9 (DGND), U44.10 (V-); also elsewhere on the board
unnamed: C124.1, R57.2
unnamed: C125.1, R58.2
unnamed: C126.1, R59.2
unnamed: C127.1, R60.2
unnamed: C128.1, R61.2
unnamed: C129.1, R62.2
unnamed: C30.1, U1.5 (Trim/NR)
unnamed: R64.2, U8.2 (-IN), U8.6 (OUTPUT)
unnamed: R4.2, U9.13 (P0A)
unnamed: C46.1, U25.5 (Trim/NR)
unnamed: R65.2, U26.2 (-IN), U26.6 (OUTPUT)
unnamed: R6.2, U27.13 (P0A)
unnamed: C56.1, U28.5 (Trim/NR)
unnamed: R66.2, U29.2 (-IN), U29.6 (OUTPUT)
unnamed: R8.2, U30.13 (P0A)
unnamed: C66.1, U31.5 (Trim/NR)
unnamed: R69.2, U32.2 (-IN), U32.6 (OUTPUT)
unnamed: R12.2, U33.13 (P0A)
unnamed: C71.1, U34.5 (Trim/NR)
unnamed: R67.2, U35.2 (-IN), U35.6 (OUTPUT)
unnamed: R16.2, U37.13 (P0A)
unnamed: C76.1, U39.5 (Trim/NR)
unnamed: R68.2, U40.2 (-IN), U40.6 (OUTPUT)
unnamed: R24.2, U44.13 (P0A)
OLED2: U8.3 (+IN), U9.12 (P0W); also elsewhere on the board
OLED3: U26.3 (+IN), U27.12 (P0W); also elsewhere on the board
OLED4: U29.3 (+IN), U30.12 (P0W); also elsewhere on the board
OLED5: U35.3 (+IN), U37.12 (P0W); also elsewhere on the board
OLED6: U40.3 (+IN), U44.12 (P0W); also elsewhere on the board
OLED7: U32.3 (+IN), U33.12 (P0W); also elsewhere on the board
VL: C32.1, C50.1, C59.1, C68.1, C73.1, C78.1, U9.1 (VL), U9.5 (A0), U9.8 (~SHDN), U27.1 (VL), U27.3 (A1), U27.8 (~SHDN), U30.1 (VL), U30.3 (A1), U30.5 (A0), U30.8 (~SHDN), U33.1 (VL), U33.3 (A1), U33.8 (~SHDN), U37.1 (VL), U37.8 (~SHDN), U44.1 (VL), U44.5 (A0), U44.8 (~SHDN); also elsewhere on the board

Notes on the sheet:
OLED is outside of this hearchical sheet Voltage over OLED is 8V when 1.5mA goes trough Voltage over OLED is 6.5V when 0.8mA goes trough
OLED Spec: 0.8 - 1.5 mA Recomended: 6.5 - 8 V Absolute maximum: 12 V
MCP45HV51T-502E/STVAO 5 k, 8-bit, 14-LD TSSOP MCP45HV51T-103E/STVAO 10 k, 8-bit, 14-LD TSSOP MCP45HV31T-503E/STVAO 50 k, 7-bit, 14-LD TSSOP MCP45HV31T-104E/MQVAO 100 k, 7-bit, 20-LD VQFN (5x5) MCP45HV51T-502E/MQVAO 5 k, 8-bit, 20-LD VQFN (5x5) MCP45HV51T-103E/MQVAO 10 k, 8-bit, 20-LD VQFN (5x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
OLED Spec: I = 0.8mA ... 1.5mA V = 6.5V ... 8V Adjusting OLED current is done by R. R consist of (constant_resistor + DigiPot) I = V_ref / R I = 2.048 / R I_min = 2.048 / R_max I_max = 2.048 / R_min Smallest resistor allowed to prevent damage: R_max = 2.048V / 0.8mA = 2560 Ohm R_min = 2.048V / 1.5m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
REF5020: TI recommends a supply bypass capacitor ranging from 1 μF to 10 μF. A 1-μF to 50-μF output capacitor (CL) must be connected from VOUT to GND. High-output current: ±10 mA 2.7 V < VIN < 18 V Calculate: VGND_MAX = 8V VIN_MIN = 8V+2.7V = 10.7V
MCP45HVX1: Analog: 10V to 36V Digital: 2.7V to 5.5V
2.048V
GND
